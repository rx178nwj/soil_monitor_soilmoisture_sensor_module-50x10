# Repository rx178nwj/soil_monitor_soilmoisture_sensor_module-50x10

File README.md:

# soil\_monitor\_soilmoisture\_sensor\_module-50x10

\# 静電容量を使用した土壌湿度センサ

\# 計測原理

パルスから静電容量の変化を計測します。

\# パルス発生機

NE555を用いてパルスを発生しています。

周波数の調整はセンサプローブの長さなどからC4の容量を調整してください。

NE555の最大周波数は500kHz程度になります

その範囲で調整します

## KiCad design soil_monitor_soilmoisture_sensor_module-50x10.kicad_pcb

Parts:
C1: C_Small; C_0603_1608Metric
C3: 1uF; C_0402_1005Metric
C4: 1nF; C_0402_1005Metric
C6: 100nF; C_0402_1005Metric
C8: 10nF; C_0402_1005Metric
C9: 1u; Soil Moisture Sensor 100x10
D1: 1N4148; D_SOD-323_HandSoldering
J1: Conn_01x04_MountingPin; TE_84953-4_amazon
R2: 1.6K; R_0402_1005Metric
R3: 330; R_0402_1005Metric
R5: 10K; R_0402_1005Metric
U1: Moisture Sensor Probe; UpperBoard
U2: NE555D; SOIC-8_3.9x4.9mm_P1.27mm
U7: Main Board; Soil_Monitor_MainBorad_100x10

Connections:
+3.3V: C1.1, C6.1, J1.2, R3.2, U2.4 (R), U2.8 (VCC)
/SoilMoistureAout: C3.1, D1.1 (K), J1.3
GND: C1.2, C3.2, C4.2, C6.2, C8.2, C9.2, J1.1, J1.MP (MountPin), U2.1 (GND)
unnamed: C9.1, D1.2 (A), R5.1
unnamed: C8.1, U2.5 (CV)
unnamed: R2.2, R3.1, U2.7 (DIS)
unnamed: R5.2, U2.3 (Q)
unnamed: C4.1, R2.1, U2.2 (TR), U2.6 (THR)

Notes on the sheet:
Soil Moisture Sensor
Ra=330 Rb=1600 C=470x10^-9 TH=0.693x(Ra+R2)xC TH 0.00062862 TL 0.000521136 f 867.9404496 Duty比 54.67422096
Soil Moisture PCB

Board: 2 copper layers, 59.5 x 59.5 mm, 14 parts (0 on the bottom side), 8 nets.
